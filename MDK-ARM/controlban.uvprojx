# Keil uVision project controlban.uvprojx, settings and files
target controlban (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: controlban +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    ..\Src;  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group user
    ../Src/: FIFO_F4.c bluetooth.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd_ex.c
  group Application/User
    ../Src/: tim.c usart.c dac.c gpio.c wwdg.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c usbd_desc.c usb_device.c usbd_conf.c machControl.c wxc_pcControl.c wxc_common.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
software components: CMSIS:CORE 4.3.0
